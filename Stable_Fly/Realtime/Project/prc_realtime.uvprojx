# Keil uVision project prc_realtime.uvprojx, settings and files
target Realtime (6180000::V6.18::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Realtime +hex
  AfterMake: fromelf.exe --binCombined -o "$L@L.bin" "#L"
  AfterMake: ../../../M7M02_Ammonite/Utility/M7M02_Final/bincopy.exe -i $L@L.bin -o ./realtime_image.c
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../M7M02_Ammonite/Include/
  asm include: ./;../Include/;../../../M7M02_Ammonite/Include/
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: prc_realtime_stm32f411ce.sct
  link misc: --keep=*_desc
  group Realtime
    ../Source/: prc_realtime_thd_startup.c prc_realtime_desc.c prc_realtime.c
  group Lib
    ../../../M7M02_Ammonite/Source/Virtlib/: rvm_virtlib.c
    ../../../M7M02_Ammonite/Source/Syslib/: rvm_syslib.c
    ../../../M7M02_Ammonite/Source/Platform/A7M/: rvm_platform_a7m_armcc.s rvm_platform_a7m.c
