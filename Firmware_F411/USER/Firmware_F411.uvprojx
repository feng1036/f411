# Keil uVision project Firmware_F411.uvprojx, settings and files
target Firmware (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Firmware_F411 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F411xE,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c misc: --preinclude stm32f4xx_conf.h --diag_suppress=767
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\CONFIG\interface;..\HARDWARE\interface;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\USB\STM32_USB_Device_Library\Core\inc;..\USB\STM32_USB_Device_Library\Class\cdc\inc;..\USB\STM32_USB_OTG_Driver\inc;..\USB\USB_APP\interface;..\FLIGHT\interface;..\COMMON\interface;..\COMMUNICATE\interface;..\EXP_MODULES\interface;..\VL53L1X;..\VL53L1X\vl53l1_platform;..\SENSOR\interface
  memory RVCT4: ROM 0x8000000 size 0x78000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER
    ../USER/: main.c
    ./: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CONFIG
    ../CONFIG/src/: config_param.c
    ../CONFIG/interface/: config_param.h FreeRTOSConfig.h
  group HARDWARE
    ../HARDWARE/src/: exti.c led.c motors.c nvic.c system.c watchdog.c
  group CORE
    ../CORE/: startup_stm32f411xe.s
  group DSP_LIB
    ../DSP_Lib/: arm_common_tables.c arm_const_structs.c arm_cos_f32.c arm_mat_mult_f32.c arm_mat_trans_f32.c arm_mean_f32.c arm_sin_f32.c
  group FreeRTOS
    ../FreeRTOS/: list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c portmacro.h
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group COMMUNICATE
    ../COMMUNICATE/src/: ledseq.c com_queue.c communicate.c
  group FLIGHT
    ../FLIGHT/src/: stabilizer.c
  group COMMON
    ../COMMON/src/: debug_assert.c freeRTOSdebug.c maths.c
  group SENSOR
    ../SENSOR/src/: sensors.c bmp280.c filter.c mpu6500.c i2c_drv.c i2cdev.c
