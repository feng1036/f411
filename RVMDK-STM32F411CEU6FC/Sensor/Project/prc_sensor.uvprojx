# Keil uVision project prc_sensor.uvprojx, settings and files
target Sensor (6180000::V6.18::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Sensor +hex
  AfterMake: fromelf.exe --binCombined -o "$L@L.bin" "#L"
  AfterMake: ../../../../Utility/M7M02_Final/bincopy.exe -i $L@L.bin -o ./sensor_image.c
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: STM32F411xE,ARM_MATH_CM4,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,__FPU_PRESENT,__FPU_USED
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../Include/;../../../../../M5P01_Prokaron/Include/;..\..\Common
  asm include: ./;../Include/;../../../../Include/;../../../../../M5P01_Prokaron/Include/
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: prc_sensor_stm32f411ce.sct
  link misc: --keep=*_desc
  group Sensor
    ../Source/: rmp_hook.c prc_sensor_desc.c prc_sensor.c
  group Lib
    ../../../../Source/Virtlib/: rvm_virtlib.c
    ../../../../Source/Syslib/: rvm_syslib.c
    ../../../../Source/Platform/A7M/: rvm_platform_a7m_armcc.s rvm_platform_a7m.c
    ../../../../../M5P01_Prokaron/Source/Platform/A7M_RVM/: rmp_platform_a7m_rvm_armcc.s rmp_platform_a7m_rvm.c
    ../../../../../M5P01_Prokaron/Source/Kernel/: rmp_kernel.c
  group User
    ../Source/: bmp280.c filter.c i2c_drv.c i2cdev.c mpu6500.c sensors.c
