# Keil uVision project kernel.uvprojx, settings and files
target Kernel (ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x08000000,0x10000) IROM(0x20000000,0x10000) CPUTYPE("Cortex-M4")  CLOCK(12000000) ELITTLE
  output: Kernel +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c misc: -Wno-unknown-warning-option -Wno-unsafe-buffer-usage -Wno-date-time -Wno-unused-parameter -Wno-missing-noreturn -Wno-unsafe-buffer-usage -Wno-missing-variable-declarations
  c include: ./;../Include/;../../../../../M7M01_Eukaron/Include/;
  asm include: ./;../Include/;../../../../../M7M01_Eukaron/Include/;
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x8000000 size 0x10000
  scatter file: rme_platform_stm32f411ce.sct
  link misc: --keep=*_image
  group Kernel
    ../Source/: rme_hook.c rme_boot.c
    ../../Sensor/Project/: sensor_image.c
    ../../Remote/Project/: remote_image.c
    ../../Realtime/Project/: realtime_image.c
    ../../Monitor/Project/: monitor_image.c
    ../../Flight/Project/: flight_image.c
  group Lib
    ../../../../../M7M01_Eukaron/Source/Platform/A7M/: rme_platform_a7m_armcc.s rme_platform_a7m.c
    ../../../../../M7M01_Eukaron/Source/Kernel/: rme_kernel.c
